<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Team1 CSE211 Project.ewp</path>
    </project>
    <batchBuild />
</workspace>
